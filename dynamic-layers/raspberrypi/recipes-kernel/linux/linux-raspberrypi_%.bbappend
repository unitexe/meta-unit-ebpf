FILESEXTRAPATHS:prepend := "${UNIT_EBPF_LAYERDIR}/recipes-kernel/linux/files:"

require recipes-kernel/linux/unit-ebpf.inc
